# Keil uVision project group_04.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.2.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(120000000) ELITTLE
  output: group_04
  c flags: Optim=1 wLevel=2
  c include: .\drivers
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group drivers
    ./drivers/: adc.c comparator.c dac.c gpio.c i2c.c timer.c uart.c adc.h comparator.h dac.h gpio.h i2c.h platform.h timer.h uart.h
  group src
    ./src/: main.c
  group io
    ./src/io/: lcd.c lcd.h leds.c leds.h switches.c switches.h lcd_roll.c lcd_roll.h eeprom.c eeprom.h eeprom_lib.c eeprom_lib.h
  group sampling
    ./src/sampling/: buffer.c buffer.h sampling.c sampling.h
  group libraries
    ./src/libraries/: delay.c delay.h stdfunc.c stdfunc.h references.h
  group fourier
    ./src/fourier/: goertzel.c goertzel.h
  group dtmf
    ./src/dtmf/: dtmf.c dtmf.h
software components: CMSIS:CORE 3.30.0, Device:Startup 1.0.0
